/* 本轮新增. Prototype Espressif development VID, default class-derived PID.
 * 303a:4041 is NOT an allocated SensorArray production product identifier.
 * Descriptor grammar follows TinyUSB MIT-licensed webusb_serial example.
 */
#include "sensorarrayUsbOtg.h"
#include <stdio.h>
#include <string.h>
#include "esp_mac.h"
#include "tusb.h"

static char s_serial[13];
void sensorarrayUsbOtgInitSerialString(void)
{
    uint8_t mac[6] = {0};
    (void)esp_efuse_mac_get_default(mac);
    snprintf(s_serial, sizeof(s_serial), "%02X%02X%02X%02X%02X%02X",
             mac[0], mac[1], mac[2], mac[3], mac[4], mac[5]);
}
static const tusb_desc_device_t s_device = {
    .bLength = sizeof(tusb_desc_device_t), .bDescriptorType = TUSB_DESC_DEVICE,
    .bcdUSB = 0x0201, .bDeviceClass = TUSB_CLASS_MISC,
    .bDeviceSubClass = MISC_SUBCLASS_COMMON, .bDeviceProtocol = MISC_PROTOCOL_IAD,
    .bMaxPacketSize0 = 64, .idVendor = 0x303a, .idProduct = 0x4041,
    .bcdDevice = 0x0100, .iManufacturer = 1, .iProduct = 2,
    .iSerialNumber = 3, .bNumConfigurations = 1,
};
const uint8_t *tud_descriptor_device_cb(void) { return (const uint8_t *)&s_device; }
#define USB_CONFIG_BYTES (TUD_CONFIG_DESC_LEN + 2*TUD_VENDOR_DESC_LEN + TUD_CDC_DESC_LEN)
/* Vendor subclass 0x53 / protocol DATA=1 CTRL=2 prevent selecting ROM JTAG.
 * Separate IN byte streams MUST be independently framed by the host. */
#define SA_VENDOR(itf, str, out, in, role) \
    9, TUSB_DESC_INTERFACE, itf, 0, 2, TUSB_CLASS_VENDOR_SPECIFIC, 0x53, role, str, \
    7, TUSB_DESC_ENDPOINT, out, TUSB_XFER_BULK, U16_TO_U8S_LE(64), 0, \
    7, TUSB_DESC_ENDPOINT, in, TUSB_XFER_BULK, U16_TO_U8S_LE(64), 0
static const uint8_t s_configuration[] = {
    TUD_CONFIG_DESCRIPTOR(1, 4, 0, USB_CONFIG_BYTES, 0, 100),
    SA_VENDOR(0, 4, 0x01, 0x81, 1),
    SA_VENDOR(1, 5, 0x02, 0x82, 2),
    TUD_CDC_DESCRIPTOR(2, 6, 0x83, 8, 0x04, 0x84, 64),
};
_Static_assert(sizeof(s_configuration) == USB_CONFIG_BYTES, "USB configuration length");
const uint8_t *tud_descriptor_configuration_cb(uint8_t index)
{ return index == 0 ? s_configuration : NULL; }

#define SA_MS_OS_BYTES 338u
#define SA_MS_OS_REQUEST 0x20u
static const uint8_t s_bos[] = {
    TUD_BOS_DESCRIPTOR(TUD_BOS_DESC_LEN + TUD_BOS_MICROSOFT_OS_DESC_LEN, 1),
    TUD_BOS_MS_OS_20_DESCRIPTOR(SA_MS_OS_BYTES, SA_MS_OS_REQUEST),
};
const uint8_t *tud_descriptor_bos_cb(void) { return s_bos; }
/* MS OS 2.0 WINUSB subsets apply only to the two vendor interfaces; the CDC
 * function remains owned by the system serial driver. Unique stable GUIDs. */
static const uint8_t s_msOs[] = {
    0x0a, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x52, 0x01, 0x08, 0x00, 0x01, 0x00, 0x00, 0x00,
    0x48, 0x01, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0xa0, 0x00, 0x14, 0x00, 0x03, 0x00, 0x57, 0x49,
    0x4e, 0x55, 0x53, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0x00,
    0x04, 0x00, 0x07, 0x00, 0x2a, 0x00, 0x44, 0x00, 0x65, 0x00, 0x76, 0x00, 0x69, 0x00, 0x63, 0x00,
    0x65, 0x00, 0x49, 0x00, 0x6e, 0x00, 0x74, 0x00, 0x65, 0x00, 0x72, 0x00, 0x66, 0x00, 0x61, 0x00,
    0x63, 0x00, 0x65, 0x00, 0x47, 0x00, 0x55, 0x00, 0x49, 0x00, 0x44, 0x00, 0x73, 0x00, 0x00, 0x00,
    0x50, 0x00, 0x7b, 0x00, 0x46, 0x00, 0x41, 0x00, 0x35, 0x00, 0x34, 0x00, 0x41, 0x00, 0x32, 0x00,
    0x43, 0x00, 0x33, 0x00, 0x2d, 0x00, 0x38, 0x00, 0x39, 0x00, 0x30, 0x00, 0x44, 0x00, 0x2d, 0x00,
    0x35, 0x00, 0x41, 0x00, 0x38, 0x00, 0x44, 0x00, 0x2d, 0x00, 0x42, 0x00, 0x32, 0x00, 0x37, 0x00,
    0x44, 0x00, 0x2d, 0x00, 0x37, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x35, 0x00, 0x39, 0x00,
    0x33, 0x00, 0x46, 0x00, 0x38, 0x00, 0x37, 0x00, 0x33, 0x00, 0x41, 0x00, 0x7d, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0xa0, 0x00, 0x14, 0x00, 0x03, 0x00, 0x57, 0x49,
    0x4e, 0x55, 0x53, 0x42, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x84, 0x00,
    0x04, 0x00, 0x07, 0x00, 0x2a, 0x00, 0x44, 0x00, 0x65, 0x00, 0x76, 0x00, 0x69, 0x00, 0x63, 0x00,
    0x65, 0x00, 0x49, 0x00, 0x6e, 0x00, 0x74, 0x00, 0x65, 0x00, 0x72, 0x00, 0x66, 0x00, 0x61, 0x00,
    0x63, 0x00, 0x65, 0x00, 0x47, 0x00, 0x55, 0x00, 0x49, 0x00, 0x44, 0x00, 0x73, 0x00, 0x00, 0x00,
    0x50, 0x00, 0x7b, 0x00, 0x38, 0x00, 0x31, 0x00, 0x37, 0x00, 0x34, 0x00, 0x43, 0x00, 0x41, 0x00,
    0x36, 0x00, 0x35, 0x00, 0x2d, 0x00, 0x33, 0x00, 0x37, 0x00, 0x33, 0x00, 0x38, 0x00, 0x2d, 0x00,
    0x35, 0x00, 0x30, 0x00, 0x34, 0x00, 0x45, 0x00, 0x2d, 0x00, 0x38, 0x00, 0x46, 0x00, 0x36, 0x00,
    0x42, 0x00, 0x2d, 0x00, 0x46, 0x00, 0x38, 0x00, 0x41, 0x00, 0x43, 0x00, 0x44, 0x00, 0x37, 0x00,
    0x45, 0x00, 0x41, 0x00, 0x35, 0x00, 0x32, 0x00, 0x35, 0x00, 0x34, 0x00, 0x7d, 0x00, 0x00, 0x00,
    0x00, 0x00,
};
_Static_assert(sizeof(s_msOs) == SA_MS_OS_BYTES, "MS OS descriptor length");
bool tud_vendor_control_xfer_cb(uint8_t rhport, uint8_t stage, const tusb_control_request_t *request)
{
    if (stage != CONTROL_STAGE_SETUP) { return true; }
    if (request->bmRequestType == 0xc0 && request->bRequest == SA_MS_OS_REQUEST &&
        request->wIndex == 7 && request->wValue == 0) {
        return tud_control_xfer(rhport, request, (void *)s_msOs, sizeof(s_msOs));
    }
    return false;
}
const uint16_t *tud_descriptor_string_cb(uint8_t index, uint16_t language)
{
    (void)language;
    static uint16_t text[48];
    static const char *const strings[] = {NULL, "SensorArray development", "SensorArray OTG data",
        s_serial, "SensorArray DATA v1", "SensorArray CTRL v1", "SensorArray debug"};
    if (index == 0) { text[0] = 0x0304; text[1] = 0x0409; return text; }
    if (index >= sizeof(strings)/sizeof(strings[0])) { return NULL; }
    size_t n = strlen(strings[index]);
    if (n > 47) { n = 47; }
    text[0] = (uint16_t)((TUSB_DESC_STRING << 8) | (2*n+2));
    for (size_t i = 0; i < n; ++i) { text[i+1] = (uint8_t)strings[index][i]; }
    return text;
}
